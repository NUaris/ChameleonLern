# Keil uVision project nfctag.uvprojx, settings and files
target nrf52 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\sdk\components;..\sdk\components\ble\ble_advertising;..\sdk\components\ble\ble_dtm;..\sdk\components\ble\ble_link_ctx_manager;..\sdk\components\ble\ble_racp;..\sdk\components\ble\ble_services\ble_ancs_c;..\sdk\components\ble\ble_services\ble_ans_c;..\sdk\components\ble\ble_services\ble_bas;..\sdk\components\ble\ble_services\ble_bas_c;..\sdk\components\ble\ble_services\ble_cscs;..\sdk\components\ble\ble_services\ble_cts_c;..\sdk\components\ble\ble_services\ble_dfu;..\sdk\components\ble\ble_services\ble_dis;..\sdk\components\ble\ble_services\ble_gls;..\sdk\components\ble\ble_services\ble_hids;..\sdk\components\ble\ble_services\ble_hrs;..\sdk\components\ble\ble_services\ble_hrs_c;..\sdk\components\ble\ble_services\ble_hts;..\sdk\components\ble\ble_services\ble_ias;..\sdk\components\ble\ble_services\ble_ias_c;..\sdk\components\ble\ble_services\ble_lbs;..\sdk\components\ble\ble_services\ble_lbs_c;..\sdk\components\ble\ble_services\ble_lls;..\sdk\components\ble\ble_services\ble_nus;..\sdk\components\ble\ble_services\ble_nus_c;..\sdk\components\ble\ble_services\ble_rscs;..\sdk\components\ble\ble_services\ble_rscs_c;..\sdk\components\ble\ble_services\ble_tps;..\sdk\components\ble\common;..\sdk\components\ble\nrf_ble_gatt;..\sdk\components\ble\nrf_ble_qwr;..\sdk\components\ble\peer_manager;..\sdk\components\boards;..\sdk\components\libraries\atomic;..\sdk\components\libraries\atomic_fifo;..\sdk\components\libraries\atomic_flags;..\sdk\components\libraries\balloc;..\sdk\components\libraries\bootloader\ble_dfu;..\sdk\components\libraries\bsp;..\sdk\components\libraries\button;..\sdk\components\libraries\cli;..\sdk\components\libraries\crc16;..\sdk\components\libraries\crc32;..\sdk\components\libraries\crypto;..\sdk\components\libraries\csense;..\sdk\components\libraries\csense_drv;..\sdk\components\libraries\delay;..\sdk\components\libraries\ecc;..\sdk\components\libraries\experimental_section_vars;..\sdk\components\libraries\experimental_task_manager;..\sdk\components\libraries\fds;..\sdk\components\libraries\fifo;..\sdk\components\libraries\fstorage;..\sdk\components\libraries\gfx;..\sdk\components\libraries\gpiote;..\sdk\components\libraries\hardfault;..\sdk\components\libraries\hci;..\sdk\components\libraries\led_softblink;..\sdk\components\libraries\log;..\sdk\components\libraries\log\src;..\sdk\components\libraries\low_power_pwm;..\sdk\components\libraries\mem_manager;..\sdk\components\libraries\memobj;..\sdk\components\libraries\mpu;..\sdk\components\libraries\mutex;..\sdk\components\libraries\pwm;..\sdk\components\libraries\pwr_mgmt;..\sdk\components\libraries\queue;..\sdk\components\libraries\ringbuf;..\sdk\components\libraries\scheduler;..\sdk\components\libraries\sdcard;..\sdk\components\libraries\slip;..\sdk\components\libraries\sortlist;..\sdk\components\libraries\spi_mngr;..\sdk\components\libraries\stack_guard;..\sdk\components\libraries\strerror;..\sdk\components\libraries\svc;..\sdk\components\libraries\timer;..\sdk\components\libraries\twi_mngr;..\sdk\components\libraries\twi_sensor;..\sdk\components\libraries\uart;..\sdk\components\libraries\usbd;..\sdk\components\libraries\usbd\class\audio;..\sdk\components\libraries\usbd\class\cdc;..\sdk\components\libraries\usbd\class\cdc\acm;..\sdk\components\libraries\usbd\class\hid;..\sdk\components\libraries\usbd\class\hid\generic;..\sdk\components\libraries\usbd\class\hid\kbd;..\sdk\components\libraries\usbd\class\hid\mouse;..\sdk\components\libraries\usbd\class\msc;..\sdk\components\libraries\util;..\sdk\components\nfc\ndef\conn_hand_parser;..\sdk\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\sdk\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\sdk\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\sdk\components\nfc\ndef\connection_handover\ac_rec;..\sdk\components\nfc\ndef\connection_handover\ble_oob_advdata;..\sdk\components\nfc\ndef\connection_handover\ble_pair_lib;..\sdk\components\nfc\ndef\connection_handover\ble_pair_msg;..\sdk\components\nfc\ndef\connection_handover\common;..\sdk\components\nfc\ndef\connection_handover\ep_oob_rec;..\sdk\components\nfc\ndef\connection_handover\hs_rec;..\sdk\components\nfc\ndef\connection_handover\le_oob_rec;..\sdk\components\nfc\ndef\generic\message;..\sdk\components\nfc\ndef\generic\record;..\sdk\components\nfc\ndef\launchapp;..\sdk\components\nfc\ndef\parser\message;..\sdk\components\nfc\ndef\parser\record;..\sdk\components\nfc\ndef\text;..\sdk\components\nfc\ndef\uri;..\sdk\components\nfc\platform;..\sdk\components\nfc\t2t_lib;..\sdk\components\nfc\t2t_parser;..\sdk\components\nfc\t4t_lib;..\sdk\components\nfc\t4t_parser\apdu;..\sdk\components\nfc\t4t_parser\cc_file;..\sdk\components\nfc\t4t_parser\hl_detection_procedure;..\sdk\components\nfc\t4t_parser\tlv;..\sdk\components\softdevice\common;..\sdk\components\softdevice\s140\headers;..\sdk\components\softdevice\s140\headers\nrf52;..\sdk\external\fprintf;..\sdk\external\segger_rtt;..\sdk\external\utf_converter;..\sdk\integration\nrfx;..\sdk\integration\nrfx\legacy;..\sdk\modules\nrfx;..\sdk\modules\nrfx\drivers\include;..\sdk\modules\nrfx\hal;..\sdk\config;..\app\bsp;..\app\rfid;..\app\rfid\reader;..\app\rfid\nfctag;..\app\rfid\reader\hf;..\app\rfid\reader\lf;..\app\rfid\nfctag\hf;..\app\rfid\nfctag\lf;..\app;..\app\utils;..\app\selection
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=7,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\sdk\config;..\sdk\components;..\sdk\components\ble\ble_advertising;..\sdk\components\ble\ble_dtm;..\sdk\components\ble\ble_link_ctx_manager;..\sdk\components\ble\ble_racp;..\sdk\components\ble\ble_services\ble_ancs_c;..\sdk\components\ble\ble_services\ble_ans_c;..\sdk\components\ble\ble_services\ble_bas;..\sdk\components\ble\ble_services\ble_bas_c;..\sdk\components\ble\ble_services\ble_cscs;..\sdk\components\ble\ble_services\ble_cts_c;..\sdk\components\ble\ble_services\ble_dfu;..\sdk\components\ble\ble_services\ble_dis;..\sdk\components\ble\ble_services\ble_gls;..\sdk\components\ble\ble_services\ble_hids;..\sdk\components\ble\ble_services\ble_hrs;..\sdk\components\ble\ble_services\ble_hrs_c;..\sdk\components\ble\ble_services\ble_hts;..\sdk\components\ble\ble_services\ble_ias;..\sdk\components\ble\ble_services\ble_ias_c;..\sdk\components\ble\ble_services\ble_lbs;..\sdk\components\ble\ble_services\ble_lbs_c;..\sdk\components\ble\ble_services\ble_lls;..\sdk\components\ble\ble_services\ble_nus;..\sdk\components\ble\ble_services\ble_nus_c;..\sdk\components\ble\ble_services\ble_rscs;..\sdk\components\ble\ble_services\ble_rscs_c;..\sdk\components\ble\ble_services\ble_tps;..\sdk\components\ble\common;..\sdk\components\ble\nrf_ble_gatt;..\sdk\components\ble\nrf_ble_qwr;..\sdk\components\ble\peer_manager;..\sdk\components\boards;..\sdk\components\libraries\atomic;..\sdk\components\libraries\atomic_fifo;..\sdk\components\libraries\atomic_flags;..\sdk\components\libraries\balloc;..\sdk\components\libraries\bootloader\ble_dfu;..\sdk\components\libraries\bsp;..\sdk\components\libraries\button;..\sdk\components\libraries\cli;..\sdk\components\libraries\crc16;..\sdk\components\libraries\crc32;..\sdk\components\libraries\crypto;..\sdk\components\libraries\csense;..\sdk\components\libraries\csense_drv;..\sdk\components\libraries\delay;..\sdk\components\libraries\ecc;..\sdk\components\libraries\experimental_section_vars;..\sdk\components\libraries\experimental_task_manager;..\sdk\components\libraries\fds;..\sdk\components\libraries\fifo;..\sdk\components\libraries\fstorage;..\sdk\components\libraries\gfx;..\sdk\components\libraries\gpiote;..\sdk\components\libraries\hardfault;..\sdk\components\libraries\hci;..\sdk\components\libraries\led_softblink;..\sdk\components\libraries\log;..\sdk\components\libraries\log\src;..\sdk\components\libraries\low_power_pwm;..\sdk\components\libraries\mem_manager;..\sdk\components\libraries\memobj;..\sdk\components\libraries\mpu;..\sdk\components\libraries\mutex;..\sdk\components\libraries\pwm;..\sdk\components\libraries\pwr_mgmt;..\sdk\components\libraries\queue;..\sdk\components\libraries\ringbuf;..\sdk\components\libraries\scheduler;..\sdk\components\libraries\sdcard;..\sdk\components\libraries\slip;..\sdk\components\libraries\sortlist;..\sdk\components\libraries\spi_mngr;..\sdk\components\libraries\stack_guard;..\sdk\components\libraries\strerror;..\sdk\components\libraries\svc;..\sdk\components\libraries\timer;..\sdk\components\libraries\twi_mngr;..\sdk\components\libraries\twi_sensor;..\sdk\components\libraries\uart;..\sdk\components\libraries\usbd;..\sdk\components\libraries\usbd\class\audio;..\sdk\components\libraries\usbd\class\cdc;..\sdk\components\libraries\usbd\class\cdc\acm;..\sdk\components\libraries\usbd\class\hid;..\sdk\components\libraries\usbd\class\hid\generic;..\sdk\components\libraries\usbd\class\hid\kbd;..\sdk\components\libraries\usbd\class\hid\mouse;..\sdk\components\libraries\usbd\class\msc;..\sdk\components\libraries\util;..\sdk\components\nfc\ndef\conn_hand_parser;..\sdk\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\sdk\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\sdk\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\sdk\components\nfc\ndef\connection_handover\ac_rec;..\sdk\components\nfc\ndef\connection_handover\ble_oob_advdata;..\sdk\components\nfc\ndef\connection_handover\ble_pair_lib;..\sdk\components\nfc\ndef\connection_handover\ble_pair_msg;..\sdk\components\nfc\ndef\connection_handover\common;..\sdk\components\nfc\ndef\connection_handover\ep_oob_rec;..\sdk\components\nfc\ndef\connection_handover\hs_rec;..\sdk\components\nfc\ndef\connection_handover\le_oob_rec;..\sdk\components\nfc\ndef\generic\message;..\sdk\components\nfc\ndef\generic\record;..\sdk\components\nfc\ndef\launchapp;..\sdk\components\nfc\ndef\parser\message;..\sdk\components\nfc\ndef\parser\record;..\sdk\components\nfc\ndef\text;..\sdk\components\nfc\ndef\uri;..\sdk\components\nfc\platform;..\sdk\components\nfc\t2t_lib;..\sdk\components\nfc\t2t_parser;..\sdk\components\nfc\t4t_lib;..\sdk\components\nfc\t4t_parser\apdu;..\sdk\components\nfc\t4t_parser\cc_file;..\sdk\components\nfc\t4t_parser\hl_detection_procedure;..\sdk\components\nfc\t4t_parser\tlv;..\sdk\components\softdevice\common;..\sdk\components\softdevice\s132\headers;..\sdk\components\softdevice\s132\headers\nrf52;..\sdk\external\fprintf;..\sdk\external\segger_rtt;..\sdk\external\utf_converter;..\sdk\integration\nrfx;..\sdk\integration\nrfx\legacy;..\sdk\modules\nrfx;..\sdk\modules\nrfx\drivers\include;..\sdk\modules\nrfx\hal;..\sdk\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xa0000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20006000 size 0x32000
  memory RVCT10: RAM 0x20038000 size 0x8000
  link misc: --diag_suppress 6330
  group Application
    ../app/: app_main.c ble_main.c usb_main.c rfid_main.c data_cmd.h app_status.h app_cmd.c
    ../sdk/config/: sdk_config.h
    ../app/rfid/nfctag/: tag_emulation.c tag_persistence.c tag_base_type.h
    ../app/utils/: timeslot.c syssleep.c fds_util.c dataframe.c
    ../app/dfu/: dfu_entry.c
  group Board Support
    ../app/bsp/: bsp_delay.c bsp_delay.h bsp_time.c bsp_time.h
  group UTF8/UTF16 converter
    ../sdk/external/utf_converter/: utf.c
  group nRF_BLE
    ../sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../sdk/components/ble/ble_advertising/: ble_advertising.c
    ../sdk/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../sdk/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_spi.c nrf_drv_ppi.c nrf_drv_power.c
    ../sdk/modules/nrfx/soc/: nrfx_atomic.c
    ../sdk/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nfct.c nrfx_timer.c nrfx_rng.c nrfx_spim.c nrfx_lpcomp.c nrfx_ppi.c nrfx_pwm.c nrfx_usbd.c nrfx_power.c nrfx_spi.c
    ../sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../sdk/components/libraries/button/: app_button.c
    ../sdk/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../sdk/components/libraries/fifo/: app_fifo.c
    ../sdk/components/libraries/scheduler/: app_scheduler.c
    ../sdk/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../sdk/components/libraries/hardfault/: hardfault_implementation.c
    ../sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../sdk/components/libraries/atomic_flags/: nrf_atflags.c
    ../sdk/components/libraries/atomic/: nrf_atomic.c
    ../sdk/components/libraries/balloc/: nrf_balloc.c
    ../sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../sdk/components/libraries/memobj/: nrf_memobj.c
    ../sdk/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    ../sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../sdk/components/libraries/sortlist/: nrf_sortlist.c
    ../sdk/components/libraries/strerror/: nrf_strerror.c
    ../sdk/components/libraries/uart/: retarget.c
    ../sdk/components/libraries/queue/: nrf_queue.c
    ../sdk/components/libraries/fds/: fds.c
    ../sdk/components/libraries/fstorage/: nrf_fstorage_sd.c nrf_fstorage.c
    ../sdk/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../sdk/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
  group nRF_Log
    ../sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../sdk/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group rfid_Utils
    ../app/rfid/: mf1_crapto1.h mf1_crapto1.c parity.c parity.h hex_utils.c crc_utils.c
  group rfid_HF_Reader
    ../app/rfid/reader/hf/: mf1_toolbox.c mf1_toolbox.h rc522.c rc522.h
  group rfid_HF_Tag
    ../app/rfid/nfctag/hf/: nfc_14a.c nfc_14a.h nfc_mf1.c nfc_mf1.h crypto1_helper.h crypto1_helper.c
  group rfid_LF_Tag
    ../app/rfid/nfctag/lf/: lf_tag_em.c lf_tag_em.h
  group rfid_LF_Reader
    ../app/rfid/reader/lf/: data_utils.c lf_em410x_data.c lf_reader_data.c lf_125khz_radio.c lf_t55xx_data.c lf_reader_main.c
  group selection
    ../app/selection/: selection.c selection_core.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.40.3
